# IAR project vga_board.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HSE_VALUE=8000000; USE_STDPERIPH_DRIVER; STM32F429_439xx
  ICCARM.CCIncludePath2: $PROJ_DIR$; sd_card; sd_card\FatFS; STM32F4xx_StdPeriph_Driver\inc; fake86; STM32_USB_HOST_Library\Core\inc; D:\MYPROGS\STM32F4\STM32F429\Firmware\stm32_fake86\STM32_USB_HOST_Library\Class\HID\inc; user_usb; D:\MYPROGS\STM32F4\STM32F429\Firmware\stm32_fake86\STM32_USB_OTG_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: D:\MYPROGS\STM32F4\STM32F429\Firmware\stm32_fake86\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group fake86
    fake86/: config.h cpu.c disk.c fake86_main.c i8253.c i8259.c input.c ports.c pseudoSDL.c render.c text_render.c timing.c video.c
  group sd_card
    sd_card/FatFS/: diskio.c ff.c
    sd_card/: sd_card_reader.c sdcard.c syscall.c
  group Startup
    ./: startup_stm32f429_439xx.s system_stm32f4xx.c
  group std_periph_driver
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group usb_host
    STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c
  group User
    ./: 32f429_lcd.c 32f429_sdram.c main.c stm32f4xx_it.c
  group user_usb
    user_usb/: usb_bsp.c usb_conf.h usbh_conf.h usbh_usr.c usbh_usr.h
